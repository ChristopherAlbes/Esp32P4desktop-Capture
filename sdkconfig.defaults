## sdkconfig.defaults
```kconfig
CONFIG_ESP_HOSTED_ENABLED=y
CONFIG_ESP_HOSTED_TRANSPORT_SPI=y
CONFIG_ESP_HOSTED_MODE_HOST=y
CONFIG_ESP_HOSTED_IDF_SLAVE_TARGET="esp32c6"
```
